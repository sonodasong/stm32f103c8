# Keil uVision project stm32f103c8_ucos-ii_eeprom.uvproj, settings and files
target src (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32f103c8_ucos-ii_eeprom +hex
  c flags: Optim=1
  c include: .\src\cmsis;.\src\ucos-ii\ports;.\src\ucos-ii\source;.\src\ucos-ii\app;.\src\library;.\src\user
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group cmsis
    ./src/cmsis/: core_cm3.c startup_stm32f10x_md.s system_stm32f10x.c
  group ucos-ii_ports
    ./src/ucos-ii/ports/: os_cpu_a.s os_cpu_c.c os_dbg.c
  group ucos-ii_source
    ./src/ucos-ii/source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group ucos-ii_app
    ./src/ucos-ii/app/: app_hooks.c
  group library
    ./src/library/: usart1.c util.c flash.c eeprom.c
  group user
    ./src/user/: main.c task.c
