# Keil uVision project stm32f103c8_ucos-ii_skin_device_v1.uvproj, settings and files
target src (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32f103c8_ucos-ii_skin_device_v1 +hex
  c flags: Optim=1
  c include: .\src\cmsis;.\src\ucos-ii\ports;.\src\ucos-ii\source;.\src\ucos-ii\app;.\src\library
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group cmsis
    ./src/cmsis/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group ucos-ii_ports
    ./src/ucos-ii/ports/: os_cpu_a.s os_dbg.c os_cpu_c.c
  group ucos-ii_source
    ./src/ucos-ii/source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group ucos-ii_app
    ./src/ucos-ii/app/: app_hooks.c
  group library
    ./src/library/: util.c i2c1.c usart1_pending.c mpu6050_port.c mpu6050.c mpu6050_9_axis.c pwm.c spi1.c nrf24l01p_port.c nrf24l01p.c led.c usart1.c eeprom.c adc1.c
  group user
    ./src/user/: main.c task.c
